options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\User\Downloads\wwd.mp3juice.blog - Ricky Montgomery - Mr Loverman (Official Lyric Video) (320 KBps).wav
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '50'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 105e6
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '60'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
