options:
  parameters:
    author: raspi4b
    generate_options: qt_gui
    id: hakrf_multi_frequency
    output_language: python
    title: Monitoring Spektrum Frekuensi dengah Hack RF
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_entry
  parameters:
    type: real
    value: stop_frek-start_frek
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
    widget: dial
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 96.5e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: run_control
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 1,0,1,1
    initPressed: 'True'
    label: Pause/Resume
    pressed: '1'
    released: '0'
    type: bool
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: start_frek
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Start Frekuensi
    type: real
    value: 87e6
  states: {}
- name: stop_frek
  id: variable_qtgui_entry
  parameters:
    label: STop Frekuensi
    type: real
    value: 108e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.4e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 48e4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if run_control else 0.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if run_control else 0.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if run_control else 0.0
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '40'
    freq0: (start_frek+stop_frek)/2
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: 8e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: stop_frek-start_frek
    color1: '"red"'
    ctrlpanel: 'True'
    fc: (start_frek+stop_frek)/2
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: Sinyal Setelah Mixing (Monitoring hasil translasi ke baseband)
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: stop_frek-start_frek
    fc: (start_frek+stop_frek)/2
    fftsize: '1024'
    gui_hint: 0,1,1,1
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
