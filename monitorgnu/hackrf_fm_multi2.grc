options:
  parameters:
    author: raspi4b
    generate_options: qt_gui
    id: hakrf_multi_frequency
    output_language: python
    title: Monitoring Spektrum Frekuensi dengan HackRF One
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_entry
  parameters:
    type: real
    value: stop_frek-start_frek
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 96.5e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: rentang_frekuensi
  id: variable_qtgui_chooser
  parameters:
    label: pita frekuensi
    labels: '["87-108", "108-137", "137-174", "174-230", "300-430", "430-460", "460-470", "478-806", "806-880", "925-960", "1427-1518", "1805-1880", "2110-2170", "2170-2200", "2300-2400"]'
    num_opts: '0'
    options: '[97.5e6, 122.5e6, 155.5e6, 202e6, 365e6, 445e6, 465e6, 642e6, 843e6, 942.5e6, 1472.5e6, 1842.5e6, 2140e6, 2185e6, 2350e6]'
    type: real
    value: 97.5e6
  states: {}
- name: run_control
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 1,0,1,1
    initPressed: 'True'
    label: Pause/Resume
    pressed: '1'
    released: '0'
    type: bool
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: start_frek
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Start Frekuensi
    type: real
    value: 87e6
  states: {}
- name: stop_frek
  id: variable_qtgui_entry
  parameters:
    label: STop Frekuensi
    type: real
    value: 108e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.4e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if run_control else 0.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if run_control else 0.0
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '40'
    freq0: (start_frek+stop_frek)/2
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: 8e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: stop_frek-start_frek
    color1: '"red"'
    ctrlpanel: 'True'
    fc: (start_frek+stop_frek)/2
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: Sinyal Setelah Mixing (Monitoring hasil translasi ke baseband)
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: stop_frek-start_frek
    fc: (start_frek+stop_frek)/2
    fftsize: '1024'
    gui_hint: 0,1,1,1
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
