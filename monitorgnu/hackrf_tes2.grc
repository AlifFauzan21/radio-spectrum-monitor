options:
  parameters:
    author: raspi4b
    generate_options: qt_gui
    id: hakrf_single_frequency
    output_language: python
    title: Monitoring Spektrum Frekuensi dengan Hack RF
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
    widget: dial
  states: {}
- name: center_frek
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Frekuensi
    type: real
    value: 100e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 96.5e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: pilih_modulasi
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: run_control
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 1,0,1,1
    initPressed: 'True'
    label: Pause/Resume
    pressed: '1'
    released: '0'
    type: bool
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sampling_rate
  id: variable_qtgui_chooser
  parameters:
    label: span
    labels: '[''1 kHz'', ''5 kHz'', ''6.25 kHz'', ''7.5 kHz'', ''10 kHz'', ''15 kHz'', ''20 kHz'', ''50 kHz'', ''100 kHz'', ''1 MHz'', ''10 MHz'', ''20 MHz'']'
    num_opts: '0'
    options: '[1e3, 5e3, 6.25e3, 7.5e3, 10e3, 15e3, 20e3, 50e3, 100e3, 1e6, 10e6, 20e6]'
    type: real
    value: 20e6
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.4e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 48e4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_2
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if run_control else 0.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '5'
    num_outputs: '5'
    output_index: '0'
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '  25e3'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '40'
    corr0: (-2.6e6 / center_frek) * 1e6
    freq0: center_frek
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sampling_rate
    color1: '"red"'
    ctrlpanel: 'True'
    fc: center_frek
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    name: Sinyal Setelah Mixing (Monitoring hasil translasi ke baseband)
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sampling_rate
    fc: center_frek
    fftsize: '1024'
    gui_hint: 0,0,1,1
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    type: fff
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_selector_0, '3']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_selector_0, '4']
- [blocks_complex_to_float_0, '0', blocks_selector_0, '1']
- [blocks_complex_to_float_1, '0', blocks_selector_0, '2']
- [blocks_complex_to_float_2, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', analog_am_demod_cf_0, '0']
- [blocks_float_to_complex_1, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0_2, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0_1, '0']
- [blocks_multiply_const_vxx_0_2, '0', audio_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_2, '0', low_pass_filter_2, '0']
- [blocks_multiply_const_vxx_2_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_4, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_selector_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0, '2', blocks_multiply_const_vxx_0_2, '0']
- [blocks_selector_0, '3', blocks_multiply_const_vxx_0_1, '0']
- [blocks_selector_0, '4', blocks_multiply_const_vxx_0_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_const_vxx_4, '0']
- [hilbert_fc_1, '0', blocks_multiply_const_vxx_2, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_2, '0']
- [low_pass_filter_1, '0', blocks_complex_to_float_1, '0']
- [low_pass_filter_2, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_2_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_1, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
