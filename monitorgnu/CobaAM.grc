options:
  parameters:
    generate_options: qt_gui
    id: am_transmitter
    output_language: python
    title: am_transmitter
  states: {}

blocks:
- name: antenna_gain
  id: variable_qtgui_range
  parameters:
    label: antenna_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '0.5'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: intermediate_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: low_pass_cutoff
  id: variable
  parameters:
    value: audio_samp_rate/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: upsample_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    start: '0'
    step: '0.05'
    stop: '10'
    value: '1'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      WAV file
      Fs=44100 Hz, 16 bits
    file: C:\Users\User\Downloads\wwd.mp3juice.blog - Ricky Montgomery - Mr Loverman (Official Lyric Video) (320 KBps).wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 18e3
    gain: '1'
    interp: '1'
    samp_rate: '44100'
    type: interp_fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: audio
    bw: samp_rate
    fc: 123e6
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    alias: upsampled_audio
    bw: samp_rate
    fc: 123e6
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Upsampled Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    alias: upsampled_filtered_audio
    bw: '500000'
    fc: 123e6
    fftsize: '1024'
    gui_hint: tab@2
    name: '"Upsampled Filtered Audio FFT (Hz)"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    fbw: '0.4'
    interp: '500000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '500000'
    fbw: '0.4'
    interp: '44100'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Audio
    label1: Upsampled audio
    label2: upsampled filtered audio
    label3: AM After Downsampling
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: am_tx_out
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
